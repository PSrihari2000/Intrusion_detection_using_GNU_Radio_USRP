options:
  parameters:
    author: Srihari
    generate_options: qt_gui
    id: Default
    output_language: python
    title: Receiver
  states: {}

blocks:
- name: Bandwidth
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 4e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: std_threshold
  id: variable_qtgui_range
  parameters:
    label: std threshold
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.05'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    comment: Adjust Tx gain at runtime
    label: threshold level
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.3'
  states: {}
- name: analog_agc2_xx_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '1000'
    reference: '1.0'
    type: complex
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '1000000'
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '50'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """Intrusion Detector - 1M samp_rate, no resampler needed"""
          def __init__(self, threshold=0.3, std_threshold=0.05,
                       baseline_samples=100000, samp_rate=1000000, learning_rate=0.95):
              gr.sync_block.__init__(
                  self,
                  name='Fast Intrusion Detector',
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.threshold = float(threshold)
              self.std_threshold = float(std_threshold)
              self.baseline_samples = int(baseline_samples)
              self.samp_rate = float(samp_rate)
              self.learning_rate = float(learning_rate)
              self._buf = np.empty(self.baseline_samples, dtype=np.float32)
              self._buf_idx = 0
              self.baseline_power = 0.0
              self.baseline_std = 0.0
              self.armed = False
              self.smooth_ratio = 1.0
              self.phase = 0.0
              self.detect_count = 0

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              n = len(inp)
              power = float(np.mean(inp))
              std   = float(np.std(inp))
              if not self.armed:
                  space = self.baseline_samples - self._buf_idx
                  chunk = min(n, space)
                  self._buf[self._buf_idx:self._buf_idx + chunk] = inp[:chunk]
                  self._buf_idx += chunk
                  if self._buf_idx >= self.baseline_samples:
                      self.baseline_power = float(np.mean(self._buf))
                      self.baseline_std   = float(np.std(self._buf))
                      self.smooth_ratio   = 1.0
                      self._buf = None
                      self.armed = True
                  out[:] = 0.0
                  return n
              ratio = power / (self.baseline_power + 1e-9)
              ratio = min(ratio, 10.0)
              self.smooth_ratio = (self.learning_rate * self.smooth_ratio +
                                  (1.0 - self.learning_rate) * ratio)
              ratio_alert = self.smooth_ratio > 1.0 + self.threshold
              std_alert   = std > self.baseline_std * (1.0 + self.std_threshold)
              intrusion   = ratio_alert and std_alert
              power_gate  = power > self.baseline_power * 9.0
              if intrusion and power_gate:
                  phase_step = 2.0 * np.pi * 1000.0 / self.samp_rate
                  np.sin(self.phase + phase_step *
                         np.arange(n, dtype=np.float32), out=out)
                  out *= 0.5
                  self.phase = (self.phase + phase_step * n) % (2.0 * np.pi)
              else:
                  out[:] = 0.0
                  self.phase = 0.0
              return n
    baseline_samples: '100000'
    learning_rate: '0.95'
    samp_rate: '1000000'
    std_threshold: std_threshold
    threshold: threshold
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '20000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: Bandwidth
    fc: 2.45e9
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: Bandwidth
    fc: center_freq
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: Bandwidth
    fc: center_freq
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 2.45e9
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: Bandwidth
    center_freq0: center_freq
    clock_source0: internal
    gain0: '60'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_agc2_xx_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', epy_block_1_0, '0']
- [blocks_moving_average_xx_0_0, '0', qtgui_freq_sink_x_0_0_1_0, '0']
- [epy_block_1_0, '0', audio_sink_0_0, '0']
- [epy_block_1_0, '0', qtgui_freq_sink_x_0_0_1, '0']
- [epy_block_1_0, '0', qtgui_time_sink_x_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [uhd_usrp_source_0_0, '0', analog_agc2_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
