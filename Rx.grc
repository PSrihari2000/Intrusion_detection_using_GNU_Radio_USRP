options:
  parameters:
    author: Srihari
    generate_options: qt_gui
    id: Default
    output_language: python
    title: Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: std_threshold
  id: variable_qtgui_range
  parameters:
    label: std threshold
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.05'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    comment: Adjust Tx gain at runtime
    label: threshold level
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.05'
  states: {}
- name: analog_agc2_xx_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '1000'
    reference: '1.0'
    type: complex
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '50'
    max_iter: '4000'
    scale: 1/50
    type: float
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Fast Intrusion Detector (only intruder vs clear, low delay)"""

          def __init__(self, threshold=0.15, std_threshold=0.015, baseline_samples=6000, samp_rate=48000, learning_rate = 0.7):
              gr.sync_block.__init__(
                  self,
                  name='Fast Intrusion Detector',
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )

              # --- Parameters ---
              self.threshold = threshold
              self.std_threshold = std_threshold
              self.baseline_samples = baseline_samples
              print(baseline_samples)
              self.samp_rate = samp_rate
              #---self.bias = bias ----
              self.learning_rate = learning_rate

              # --- Baseline ---
              self.baseline_buffer = []
              self.baseline_power = 0.0
              self.baseline_std = 0.0
              self.armed = False

              # --- Tone ---
              self.freq = 1000
              self.phase = 0.0

              # --- State ---
              self.last_status = ""
              self.smooth_ratio = 1.0

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]

              # --- Signal features ---
              power = np.mean(inp**2)
              std = np.std(inp)

              # ================= BASELINE LEARNING =================
              if not self.armed:
                  self.baseline_buffer.extend((inp**2).tolist())

                  if len(self.baseline_buffer) >= self.baseline_samples:
                      self.baseline_power = np.mean(self.baseline_buffer)
                      self.baseline_std = np.std(self.baseline_buffer)
                      self.armed = True

                      print("[ARMED] Baseline ready")

                  out[:] = 0
                  return len(out)

              # ================= FAST DETECTION =================
              ratio = power / (self.baseline_power + 1e-12)
              bias = 1-self.learning_rate
              #  Fast smoothing (low delay)
              self.smooth_ratio = self.learning_rate * self.smooth_ratio + bias * ratio

              ratio_alert = (self.smooth_ratio > 1.0 + self.threshold) or (self.smooth_ratio < 1.0 - self.threshold)
              std_alert = std > (self.baseline_std + self.std_threshold)

              # ================= DECISION =================
              if ratio_alert and std_alert:
                  status = "INTRUSION DETECTED"
              else:
                  status = "CLEAR"

              # --- Print only when status changes ---
              if status != self.last_status:
                  print(f"[{status}] ratio={self.smooth_ratio:.3f} std={std:.6f}")
                  self.last_status = status

              # ================= AUDIO OUTPUT =================
              t = np.arange(len(out))

              if status == "INTRUSION DETECTED":
                  out[:] = 0.5 * np.sin(2 * np.pi * self.freq * t / self.samp_rate + self.phase)

                  self.phase += 2 * np.pi * self.freq * len(out) / self.samp_rate
                  self.phase %= 2 * np.pi
              else:
                  out[:] = 0

              return len(out)
    baseline_samples: '6000'
    learning_rate: '0.8'
    samp_rate: '48000'
    std_threshold: std_threshold
    threshold: threshold
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '20000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 2.45e9
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 2.45e9
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 2.45e9
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 2.45e9
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: '1000000'
    center_freq0: 2.45e9
    clock_source0: internal
    gain0: '60'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_agc2_xx_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', epy_block_1_0, '0']
- [blocks_moving_average_xx_0_0, '0', qtgui_freq_sink_x_0_0_1_0, '0']
- [blocks_moving_average_xx_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [epy_block_1_0, '0', audio_sink_0_0, '0']
- [epy_block_1_0, '0', qtgui_freq_sink_x_0_0_1, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [uhd_usrp_source_0_0, '0', analog_agc2_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
